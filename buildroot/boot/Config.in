## buildroot/boot/Config.in
```kconfig
menu "Bootloaders"

source "boot/syslinux/Config.in"
source "boot/uboot/Config.in"

endmenu
```
